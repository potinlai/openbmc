FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://sanmigueltb.cfg"
