FILESEXTRAPATHS:prepend := "${THISDIR}/phosphor-host-postd:"

SNOOP_DEVICE:aspeed-g6 = "aspeed-lpc-pcc"
SNOOP_DEVICE:aspeed-g7 = "aspeed-lpc-pcc0"
POST_CODE_BYTES = "8"
